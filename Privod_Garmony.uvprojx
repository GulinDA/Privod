# Keil uVision project Privod_Garmony.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MDR1986BE93 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Privod_Garmony +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c Init.c Interrupts.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.5, Drivers:ADC 1.5, Drivers:DAC 1.5, Drivers:PORT 1.5, Drivers:POWER 1.5, Drivers:RST_CLK 1.5, Drivers:TIMER 1.5, Drivers:UART 1.5
